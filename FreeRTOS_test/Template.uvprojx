# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\FWLIB\CMSIS;.\FWLIB\STM32F10x_StdPeriph_Driver\inc;.\HARDWARE\led;.\SYSTEM;.\HARDWARE\rs485;.\HARDWARE\CRC;.\HARDWARE\protocol;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS;.\HARDWARE\timer;.\HARDWARE\GPRS_WIS800C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c task_app.c
  group HARDWARE
    ./HARDWARE/led/: led.c
    ./HARDWARE/rs485/: rs485.c
    ./HARDWARE/CRC/: crc16.c
    ./HARDWARE/protocol/: protocol.c
    ./HARDWARE/timer/: timer.c
    ./HARDWARE/GPRS_WIS800C/: gprs_at.c gprs_data_unit.c
  group SYSTEM
    ./SYSTEM/: system.c SysTick.c usart.c
  group FWLIB
    ./FWLIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./FWLIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FreeRTOS_CORE
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
